
INIT    EQU $DE15
DRIVE   EQU $DE0C
RESTORE EQU $DE09
READ    EQU $DE00
WRITE   EQU $DE03

SCTBUF  EQU $C200 ; DATA SECTOR BUFFER

BUFFER  EQU $C100

    ORG $020

TRACK RMB 1
SECTOR RMB 1

    ORG $0500

    JSR INIT

    LDX #SCTBUF
    CLR 3,X         ; SET DRIVE 0
    JSR DRIVE
    
    LDX #SCTBUF
    JSR RESTORE

    LDX #BUFFER

    LDA #0
    STA TRACK
    LDA #1
    STA SECTOR

    LDD TRACK
    JSR WRITE 


    RTS
